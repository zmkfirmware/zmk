#include "../behavior_keymap.dtsi"

/ {
    chosen { zmk,led-matrix = &led_matrix; };

    pixels: pixels {
        compatible = "zmk,led-mock";
        mode = "color";
        led_0 { index = <0>; color-mapping = <LED_COLOR_ID_RED LED_COLOR_ID_GREEN LED_COLOR_ID_BLUE>; };
        led_1 { index = <1>; color-mapping = <LED_COLOR_ID_RED LED_COLOR_ID_GREEN LED_COLOR_ID_BLUE>; };
        led_2 { index = <2>; color-mapping = <LED_COLOR_ID_RED LED_COLOR_ID_GREEN LED_COLOR_ID_BLUE>; };
        led_3 { index = <3>; color-mapping = <LED_COLOR_ID_RED LED_COLOR_ID_GREEN LED_COLOR_ID_BLUE>; };
    };

    led_matrix: led_matrix {
        compatible = "zmk,led-matrix";
        led-driver = "matrix";
        led-device = <&pixels>;
        led-count = <4>;
        matrix-led-grid = <0 1 LM_BREAK 3 2>;
        gradient {
            profile-id = <0>;
            renderer = "gradient";
            effect-style = <2>;
            effect-direction = "reverse";
            colors = <LM_RED>;
        };
    };
};
