#include <behaviors.dtsi>
#include <dt-bindings/zmk/keys.h>
#include <dt-bindings/zmk/kscan_mock.h>

&kscan {
    /delete-property/ exit-after;
    events =
    <ZMK_MOCK_PRESS(0,0,5000)
    ZMK_MOCK_RELEASE(0,0,1000)
    ZMK_MOCK_PRESS(0,1,1000)
    ZMK_MOCK_RELEASE(0,1,200)>;
};
/ {
    keymap {
        compatible = "zmk,keymap";

        default_layer {
            bindings = <
            &kp LSHFT &kp A
            &kp B &kp C>;
        };
    };
};
