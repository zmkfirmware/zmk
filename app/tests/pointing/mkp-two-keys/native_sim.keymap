#include <behaviors.dtsi>
#include <dt-bindings/zmk/keys.h>
#include <dt-bindings/zmk/kscan_mock.h>
#include <dt-bindings/zmk/pointing.h>
#include <zephyr/dt-bindings/input/input-event-codes.h>

/ {
    keymap {
        compatible = "zmk,keymap";

        default_layer {
            bindings = <
            &mkp LCLK &mkp LCLK
            &none     &none
            >;
        };
    };
};

&kscan {
    events = <
    ZMK_MOCK_PRESS  (0,0,100)
    ZMK_MOCK_PRESS  (0,1,100)
    ZMK_MOCK_RELEASE(0,0,100)
    ZMK_MOCK_RELEASE(0,1,100)
    >;
};
